# Keil uVision project TIMER_TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TIMER_TEST +hex
  AfterMake: D:\Keil\ARM\BIN40\fromelf.exe --bin -o ./output/TIMER_TEST.bin ./output/TIMER_TEST.axf
  c flags: Optim=1
  c include: .\S3C2440\inc;.\TFT320240
  asm include: .\S3C2440\inc
  memory RVCT1: ROM 0x0 size 0x2000000
  memory RVCT6: RAM 0x30000fff size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\common\RuninRAM.sct
  group Source Group 1
    ./: main.c
  group 2440
    ./S3C2440/inc/: Timer.h 2440addr.h 2440addr.inc 2440lib.h 2440slib.h config.h def.h Memcfg.inc memtest.h mmu.h Option.h Option.inc profile.h image320240.h image160120.h font_def.h graph.h symbol_def.h font_16x16.h Eint.h io_api.h radio_api.h config_cust.h
    ./S3C2440/src/: Timer.c 2440init.s 2440lib.c 2440slib.s mmu.c Target.c graph.c Eint.c io_api.c radio_api.c FM_I2c.c
    ./TFT320240/: LCD_TFT.c LCD_TFT.h
